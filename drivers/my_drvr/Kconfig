## drivers/my_drvr/Kconfig
```kconfig
config MY_DRIVER
tristate "my driver"
depends on ARM
default y if ARM
help
  my driver module.
```
